# Keil uVision project Led.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: E:\cources\Embeded_system\Embedded_Systems_Advanced_Program_udacity\Documen_Source\COST\LIB;E:\cources\Embeded_system\Embedded_Systems_Advanced_Program_udacity\Documen_Source\COST\MCAL\DRIVER\HW;E:\cources\Embeded_system\Embedded_Systems_Advanced_Program_udacity\Documen_Source\COST\MCAL\DRIVER\sysTick;E:\cources\Embeded_system\Embedded_Systems_Advanced_Program_udacity\Documen_Source\COST\HAL\led_Driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/APP/: main.c
  group mcal
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/MCAL/DRIVER/DIO_driver/: dio_driver2.c
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/MCAL/DRIVER/PORT_driver/: port_driver2.c
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/MCAL/DRIVER/sysTick/: STICK_program.c
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/MCAL/DRIVER/int_ctrl/: IntCtrl.c
  group HAl
    E:/cources/Embeded_system/Embedded_Systems_Advanced_Program_udacity/Documen_Source/COST/HAL/led_Driver/: led.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
